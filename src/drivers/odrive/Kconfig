## src/drivers/odrive/Kconfig
```kconfig
menuconfig DRIVERS_ODRIVE
	bool "odrive"
	default n
	---help---
		Enable support for odrive
```
